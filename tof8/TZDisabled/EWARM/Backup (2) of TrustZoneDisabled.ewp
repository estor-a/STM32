# IAR project Backup (2) of TrustZoneDisabled.ewp, settings and files
configuration NUCLEO-U385RG_Templates_Legacy (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385VG ST STM32U385VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32U385xx; USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32U3xx\Include; ..\..\..\..\..\Drivers\STM32U3xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32U3xx_Nucleo; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\VL53L4CX; ..\Src\VL53L8CX
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZoneDisabled.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u385xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/BSP
    ../Src/: adc_polling.c AE_vl53l8.c analog.c B_HMI_LCD16x2.c commons.c HabuLQFP100_SMPS.c io_drive.c Joystick.c LCD_16x2.c LEDs.c m95p32_hal_xspi.c
    ../Inc/: HabuLQFP100_SMPS.h io_drive.h m95p32_hal_xspi.h MB2095_NET.h
  group Drivers/BSP/Sensors
    ../Src/: lis2du12_reg.c platform.c sensors.c sths34pf80_reg.c VL53L4CD_api.c
    ../Inc/: lis2du12_reg.h platform.h sensors.h sths34pf80_reg.h VL53L4CD_api.h
  group Drivers/BSP/Sensors/VL53L8CX
    ../Src/VL53L8CX/: vl53l8cx_api.c vl53l8cx_api.h vl53l8cx_buffers.h vl53l8cx_platform.c vl53l8cx_platform.h vl53l8cx_plugin_detection_thresholds.c vl53l8cx_plugin_detection_thresholds.h vl53l8cx_plugin_motion_indicator.c vl53l8cx_plugin_motion_indicator.h vl53l8cx_plugin_xtalk.c vl53l8cx_plugin_xtalk.h
  group Drivers/BSP/STM32U3xx_Nucleo
    ../../../../../Drivers/BSP/STM32U3xx_Nucleo/: stm32u3xx_nucleo.c
  group Drivers/BUS
    ../Src/: I2C_MasterIO.c octospi 1.c SerialComPort.c SPI_MasterIO.c u8fifo.c
    ../Inc/: I2C_MasterIO.h LEDs.h octospi 1.h SerialComPort.h SPI_MasterIO.h u8fifo.h
  group Drivers/CLOCKS
    ../Src/: ClockTree.c ClockTree.h
  group Drivers/CMSIS
    ../Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_adc.c stm32u3xx_hal_adc_ex.c stm32u3xx_hal_ccb.c stm32u3xx_hal_comp.c stm32u3xx_hal_cortex.c stm32u3xx_hal_crc.c stm32u3xx_hal_crc_ex.c stm32u3xx_hal_cryp.c stm32u3xx_hal_cryp_ex.c stm32u3xx_hal_dac.c stm32u3xx_hal_dac_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_fdcan.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_hash.c stm32u3xx_hal_hcd.c stm32u3xx_hal_i2c.c stm32u3xx_hal_i2c_ex.c stm32u3xx_hal_i3c.c stm32u3xx_hal_icache.c stm32u3xx_hal_irda.c stm32u3xx_hal_iwdg.c stm32u3xx_hal_lptim.c stm32u3xx_hal_mdf.c stm32u3xx_hal_mmc.c stm32u3xx_hal_mmc_ex.c stm32u3xx_hal_opamp.c stm32u3xx_hal_opamp_ex.c stm32u3xx_hal_pcd.c stm32u3xx_hal_pcd_ex.c stm32u3xx_hal_pka.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_ramcfg.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_rng.c stm32u3xx_hal_rng_ex.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_sai.c stm32u3xx_hal_sai_ex.c stm32u3xx_hal_sd.c stm32u3xx_hal_sd_ex.c stm32u3xx_hal_smartcard.c stm32u3xx_hal_smartcard_ex.c stm32u3xx_hal_smbus.c stm32u3xx_hal_smbus_ex.c stm32u3xx_hal_spi.c stm32u3xx_hal_spi_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_tsc.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_usart.c stm32u3xx_hal_usart_ex.c stm32u3xx_hal_wwdg.c stm32u3xx_hal_xspi.c stm32u3xx_ll_adc.c stm32u3xx_ll_gpio.c stm32u3xx_ll_lpuart.c stm32u3xx_ll_rcc.c stm32u3xx_ll_usart.c
    ../../../../../Drivers/STM32U3xx_HAL_Driver/Inc/: stm32u3xx_ll_gpio.h
  group Example/EWARM
    ./: startup_stm32u385xx.s
  group Example/User
    ../Src/: app.c app_init.c app_polling.c brisk_reports.c BTEL_drivers.c main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
    ../../../../../../../../../Downloads/: app_mems.c app_mems.h
    ../Inc/: B_HMI_LCD16x2.h brisk_reports.h BTEL_drivers.h critical.h Joystick.h LCD_16x2.h
